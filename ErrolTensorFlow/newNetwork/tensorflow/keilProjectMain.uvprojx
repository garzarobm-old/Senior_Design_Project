# Keil uVision project keilProjectMain.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keilProjectMain
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  group main
    ./tensorflow/lite/micro/examples/micro_speech/sparkfun_edge/seniorFitSrc/main/: ble_freertos_fit_lp.c radio_task.c rtos.c
  group exactle
    ./tensorflow/lite/micro/examples/micro_speech/sparkfun_edge/seniorFitSrc/exactle/: bas_main.c bda.c bstream.c cfg_stack.c fit_main.c hid_main.c rscps_main.c wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c
