# Keil uVision project keil_project.uvprojx, settings and files
target micro_speech (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: micro_speech
  c flags: Optim=7 OneElfS=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .;third_party/gemmlowp;third_party/flatbuffers/include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: LICENSE
    tensorflow/lite/c/: builtin_op_data.h c_api_internal.c c_api_internal.h
    tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h
    tensorflow/lite/experimental/micro/: compatibility.h debug_log.cc debug_log.h debug_log_numbers.cc debug_log_numbers.h micro_error_reporter.cc micro_error_reporter.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.cc micro_mutable_op_resolver.h simple_tensor_allocator.cc simple_tensor_allocator.h
    tensorflow/lite/experimental/micro/examples/micro_speech/: audio_provider.cc audio_provider.h feature_provider.cc feature_provider.h main.cc model_settings.cc model_settings.h no_features_data.cc no_features_data.h preprocessor.cc preprocessor.h recognize_commands.cc recognize_commands.h tiny_conv_model_data.cc tiny_conv_model_data.h yes_features_data.cc yes_features_data.h
    tensorflow/lite/experimental/micro/kernels/: all_ops_resolver.cc all_ops_resolver.h depthwise_conv.cc fully_connected.cc softmax.cc
    tensorflow/lite/experimental/micro/testing/: micro_test.h test_utils.h
    tensorflow/lite/kernels/internal/: common.h compatibility.h quantization_util.cc quantization_util.h round.h tensor_ctypes.h types.h
    tensorflow/lite/kernels/internal/reference/: depthwiseconv_float.h depthwiseconv_uint8.h fully_connected.h softmax.h
    tensorflow/lite/kernels/: kernel_util.cc kernel_util.h op_macros.h padding.h
    tensorflow/lite/schema/: schema_generated.h
    tensorflow/lite/: version.h
    third_party/flatbuffers/: LICENSE.txt
    third_party/flatbuffers/include/flatbuffers/: base.h flatbuffers.h stl_emulation.h
    third_party/gemmlowp/: LICENSE
    third_party/gemmlowp/fixedpoint/: fixedpoint.h fixedpoint_sse.h
    third_party/gemmlowp/internal/: detect_platform.h
software components: Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
