# Keil uVision project keilProjectMain.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMA3B2KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.2.0
  cpu: IRAM(0x10000000,0x000C0000) IROM(0x0000C000,0x001F4000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keilProjectMain
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0xc000 size 0x1f4000
  memory RVCT9: RAM 0x10000000 size 0xc0000
  group main
    ./tensorflow/lite/micro/examples/micro_speech/sparkfun_edge/seniorFitSrc/main/: ble_freertos_fit_lp.c radio_task.c rtos.c
  group exactle
    ./tensorflow/lite/micro/examples/micro_speech/sparkfun_edge/seniorFitSrc/exactle/: bas_main.c bda.c bstream.c cfg_stack.c fit_main.c hid_main.c rscps_main.c wsf_assert.c wsf_buf.c wsf_efs.c wsf_math.c wsf_msg.c wsf_os.c wsf_queue.c wsf_timer.c wsf_trace.c hrps_main.c app_db.c app_hw.c app_main.c app_server.c app_slave.c app_ui.c hci_cmd.c hci_drv_apollo3.c sec_ecc_hci.c sec_ecc.c svc_batt.c svc_core.c svc_dis.c svc_hrs.c svc_rscs.c
  group exactle_includes
    ./tensorflow/lite/micro/examples/micro_speech/sparkfun_edge/seniorFitSrc/exactle/include/: app_api.h app_db.h app_hw.h app_ui.h att_api.h att_defs.h att_handler.h att_uuid.h bas_api.h bda.h bstream.h cfg_stack.h dm_api.h dm_handler.h fit_api.h hid_api.h hrps_api.h l2c_api.h l2c_defs.h l2c_handler.h rscp_api.h sec_api.h smp_api.h smp_defs.h smp_handler.h svc_batt.h svc_bps.h svc_cfg.h svc_ch.h svc_core.h svc_cps.h svc_cscs.h svc_dis.h svc_gls.h svc_gyro.h svc_hid.h svc_hrs.h svc_hts.h svc_ipss.h svc_plxs.h svc_px.h svc_rscs.h svc_scpss.h svc_temp.h svc_uricfg.h svc_wdxs.h svc_wp.h svc_wss.h wsf_assert.h wsf_buf.h wsf_cs.h wsf_efs.h wsf_intrinsic.h wsf_math.h wsf_msg.h wsf_os.h wsf_os_int.h wsf_queue.h wsf_timer.h wsf_trace.h wsf_types.h
